** SPICE netlist generated by bigspicy.py at Mon Dec 12 06:59:06 2022 UTC
.SUBCKT iiitb_uarttx
+ VGND VPWR clkin i_TX_DV o_TX_Active o_TX_Done o_TX_Serial i_TX_Byte.0 i_TX_Byte.1 i_TX_Byte.2 i_TX_Byte.3 i_TX_Byte.4 i_TX_Byte.5 i_TX_Byte.6 i_TX_Byte.7
** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_28 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_28_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_28_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_29 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_30 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_31 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_31_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_31_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_32 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_32_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_32_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_33 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_34 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_35 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_36 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_37 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_38 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_38_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_38_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_39 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_39_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_39_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_40 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_40_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_40_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_41 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_42 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_42_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_42_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_43 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_43_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_43_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_44 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_44_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_44_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_45 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_46 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_47 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_48 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_49 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_50 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_50_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_50_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_51 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_52 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_54 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_54_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_54_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_55 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_55_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_55_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_100 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_101 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_102 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_103 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_104 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_105 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_106 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_107 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_108 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_109 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_110 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_111 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_112 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_113 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_114 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_115 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_116 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_117 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_118 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_119 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_120 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_121 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_122 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_123 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_124 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_125 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_126 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_127 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_128 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_129 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_130 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_56 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_57 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_58 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_59 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_60 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_61 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_62 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_63 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_64 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_65 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_66 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_67 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_68 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_69 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_70 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_71 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_72 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_73 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_74 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_75 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_76 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_77 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_78 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_79 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_80 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_81 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_82 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_83 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_84 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_85 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_86 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_87 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_88 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_89 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_90 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_91 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_92 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_93 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_94 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_95 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_96 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_97 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_98 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_99 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _083_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__083__0 _083__a_253_47# _056_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__083__1 VPWR _052_ _083__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__083__2 _060_ _083__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__083__3 _060_ _083__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__083__4 VGND _052_ _083__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__083__5 _083__a_103_199# _059_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__083__6 _083__a_253_47# _059_ _083__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__083__7 VGND _057_ _083__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__083__8 _083__a_253_297# _056_ _083__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__083__9 _083__a_337_297# _057_ _083__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _084_ with the contents of sky130_fd_sc_hd__a21bo_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_215_297# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__084__0 VPWR _084__a_215_297# _080_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_297# w=1]]', 'g: [connection X1/g =>[signal: a_27_413# w=1]]', 's: [connection X1/s =>[signal: a_298_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__084__1 _084__a_215_297# _084__a_27_413# _084__a_298_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_298_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__084__2 VPWR _055_ _084__a_298_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_298_297# w=1]]', 'g: [connection X3/g =>[signal: A1 w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__084__3 _084__a_298_297# _054_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_215_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_382_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__084__4 _084__a_215_297# _054_ _084__a_382_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_413# w=1]]', 'g: [connection X5/g =>[signal: B1_N w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__084__5 _084__a_27_413# _060_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_413# w=1]]', 'g: [connection X6/g =>[signal: B1_N w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__084__6 _084__a_27_413# _060_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_215_297# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__084__7 VGND _084__a_215_297# _080_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_382_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__084__8 _084__a_382_47# _055_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_27_413# w=1]]', 's: [connection X9/s =>[signal: a_215_297# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__084__9 VGND _084__a_27_413# _084__a_215_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _085_ with the contents of sky130_fd_sc_hd__and3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_209_311# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: a_296_53# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__085__0 _085__a_209_311# _085__a_109_93# _085__a_296_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_209_311# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__085__1 VGND _085__a_209_311# _061_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: a_109_93# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__085__2 VGND _051_ _085__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_209_311# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__085__3 VPWR _085__a_209_311# _061_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: a_109_93# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__085__4 VPWR _051_ _085__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_368_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__085__5 _085__a_368_53# r_SM_Main[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_209_311# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__085__6 VPWR r_SM_Main[0] _085__a_209_311# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_209_311# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__085__7 _085__a_209_311# r_SM_Main[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_296_53# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_368_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__085__8 _085__a_296_53# r_SM_Main[0] _085__a_368_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_209_311# w=1]]', 'g: [connection X9/g =>[signal: a_109_93# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__085__9 _085__a_209_311# _085__a_109_93# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _086_ with the contents of sky130_fd_sc_hd__o41a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_393_297# w=1]]', 'g: [connection X0/g =>[signal: A3 w=1]]', 's: [connection X0/s =>[signal: a_511_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__086__0 _086__a_393_297# r_SM_Main[1] _086__a_511_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_321_47# w=1]]', 'g: [connection X1/g =>[signal: A2 w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__086__1 _086__a_321_47# _056_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_321_47# w=1]]', 'g: [connection X2/g =>[signal: A4 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__086__2 _086__a_321_47# _050_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_103_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__086__3 VPWR _053_ _086__a_103_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_321_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__086__4 VGND _052_ _086__a_321_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_21# w=1]]', 'g: [connection X5/g =>[signal: A4 w=1]]', 's: [connection X5/s =>[signal: a_393_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__086__5 _086__a_103_21# _050_ _086__a_393_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_103_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_321_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__086__6 _086__a_103_21# _053_ _086__a_321_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_103_21# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__086__7 _062_ _086__a_103_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_619_297# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__086__8 _086__a_619_297# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_511_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: a_619_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__086__9 _086__a_511_297# _056_ _086__a_619_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_103_21# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__086__10 _062_ _086__a_103_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VGND w=1]]', 'g: [connection X11/g =>[signal: A3 w=1]]', 's: [connection X11/s =>[signal: a_321_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__086__11 VGND r_SM_Main[1] _086__a_321_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _087_ with the contents of sky130_fd_sc_hd__a21bo_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_215_297# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__087__0 VPWR _087__a_215_297# _081_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_297# w=1]]', 'g: [connection X1/g =>[signal: a_27_413# w=1]]', 's: [connection X1/s =>[signal: a_298_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__087__1 _087__a_215_297# _087__a_27_413# _087__a_298_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_298_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__087__2 VPWR _061_ _087__a_298_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_298_297# w=1]]', 'g: [connection X3/g =>[signal: A1 w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__087__3 _087__a_298_297# _050_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_215_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_382_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__087__4 _087__a_215_297# _050_ _087__a_382_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_413# w=1]]', 'g: [connection X5/g =>[signal: B1_N w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__087__5 _087__a_27_413# _062_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_413# w=1]]', 'g: [connection X6/g =>[signal: B1_N w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__087__6 _087__a_27_413# _062_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_215_297# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__087__7 VGND _087__a_215_297# _081_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_382_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__087__8 _087__a_382_47# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_27_413# w=1]]', 's: [connection X9/s =>[signal: a_215_297# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__087__9 VGND _087__a_27_413# _087__a_215_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _088_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__088__0 VGND _088__a_59_75# _063_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__088__1 VPWR _057_ _088__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__088__2 _088__a_59_75# _057_ _088__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__088__3 _088__a_59_75# _061_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__088__4 _088__a_145_75# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__088__5 VPWR _088__a_59_75# _063_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _089_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__089__0 VGND _063_ _089__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__089__1 _082_ _089__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__089__2 _082_ _089__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__089__3 VPWR _063_ _089__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _091_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__091__0 _091__a_199_47# _059_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__091__1 _091__a_113_297# _064_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__091__2 _000_ _082_ _091__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__091__3 VGND _082_ _000_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__091__4 VPWR _059_ _091__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__091__5 _000_ _064_ _091__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _092_ with the contents of sky130_fd_sc_hd__nor2_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__092__0 _065_ r_SM_Main[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__092__1 VPWR r_SM_Main[0] _092__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__092__2 _065_ r_SM_Main[1] _092__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__092__3 VGND r_SM_Main[1] _065_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__092__4 _092__a_27_297# r_SM_Main[1] _065_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__092__5 _092__a_27_297# r_SM_Main[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: Y w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__092__6 VGND r_SM_Main[0] _065_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__092__7 _065_ r_SM_Main[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _093_ with the contents of sky130_fd_sc_hd__a311oi_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__093__0 _093__a_109_297# _048_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_109_297# w=1]]', 'g: [connection X1/g =>[signal: B1 w=1]]', 's: [connection X1/s =>[signal: a_1139_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__093__1 _093__a_109_297# _065_ _093__a_1139_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: A1 w=1]]', 's: [connection X2/s =>[signal: a_445_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__093__2 _066_ _048_ _093__a_445_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_27_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_445_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__093__3 _093__a_27_47# r_Clock_Count[7] _093__a_445_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__093__4 _066_ _065_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_445_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__093__5 _093__a_27_47# r_Clock_Count[7] _093__a_445_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1139_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_109_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__093__6 _093__a_1139_297# _065_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_445_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__093__7 _066_ _048_ _093__a_445_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: Y w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__093__8 _066_ _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A1 w=1]]', 's: [connection X9/s =>[signal: a_109_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__093__9 VPWR _048_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_109_297# w=1]]', 'g: [connection X10/g =>[signal: A2 w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__093__10 _093__a_109_297# r_Clock_Count[7] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1139_297# w=1]]', 'g: [connection X11/g =>[signal: C1 w=1]]', 's: [connection X11/s =>[signal: Y w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__093__11 _093__a_1139_297# _051_ _066_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_109_297# w=1]]', 'g: [connection X12/g =>[signal: A2 w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__093__12 _093__a_109_297# r_Clock_Count[7] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VGND w=1]]', 'g: [connection X13/g =>[signal: A3 w=1]]', 's: [connection X13/s =>[signal: a_27_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__093__13 VGND _049_ _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_109_297# w=1]]', 'g: [connection X14/g =>[signal: A1 w=1]]', 's: [connection X14/s =>[signal: VPWR w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__093__14 _093__a_109_297# _048_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Y w=1]]', 'g: [connection X15/g =>[signal: C1 w=1]]', 's: [connection X15/s =>[signal: a_1139_297# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__093__15 _066_ _051_ _093__a_1139_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: A2 w=1]]', 's: [connection X16/s =>[signal: a_109_297# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__093__16 VPWR r_Clock_Count[7] _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: Y w=1]]', 'g: [connection X17/g =>[signal: C1 w=1]]', 's: [connection X17/s =>[signal: a_1139_297# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__093__17 _066_ _051_ _093__a_1139_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VPWR w=1]]', 'g: [connection X18/g =>[signal: A1 w=1]]', 's: [connection X18/s =>[signal: a_109_297# w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__093__18 VPWR _048_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_445_47# w=1]]', 'g: [connection X19/g =>[signal: A2 w=1]]', 's: [connection X19/s =>[signal: a_27_47# w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__093__19 _093__a_445_47# r_Clock_Count[7] _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X20 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VGND w=1]]', 'g: [connection X20/g =>[signal: B1 w=1]]', 's: [connection X20/s =>[signal: Y w=1]]', 'b: [connection X20/b =>[signal: VNB w=1]]']]
X__093__20 VGND _065_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1139_297# w=1]]', 'g: [connection X21/g =>[signal: C1 w=1]]', 's: [connection X21/s =>[signal: Y w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__093__21 _093__a_1139_297# _051_ _066_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: C1 w=1]]', 's: [connection X22/s =>[signal: Y w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__093__22 VGND _051_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_27_47# w=1]]', 'g: [connection X23/g =>[signal: A3 w=1]]', 's: [connection X23/s =>[signal: VGND w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__093__23 _093__a_27_47# _049_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VGND w=1]]', 'g: [connection X24/g =>[signal: A3 w=1]]', 's: [connection X24/s =>[signal: a_27_47# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__093__24 VGND _049_ _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VPWR w=1]]', 'g: [connection X25/g =>[signal: A3 w=1]]', 's: [connection X25/s =>[signal: a_109_297# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__093__25 VPWR _049_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X26 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: a_27_47# w=1]]', 'g: [connection X26/g =>[signal: A3 w=1]]', 's: [connection X26/s =>[signal: VGND w=1]]', 'b: [connection X26/b =>[signal: VNB w=1]]']]
X__093__26 _093__a_27_47# _049_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: Y w=1]]', 'g: [connection X27/g =>[signal: B1 w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__093__27 _066_ _065_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: A2 w=1]]', 's: [connection X28/s =>[signal: a_109_297# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__093__28 VPWR r_Clock_Count[7] _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VPWR w=1]]', 'g: [connection X29/g =>[signal: A3 w=1]]', 's: [connection X29/s =>[signal: a_109_297# w=1]]', 'b: [connection X29/b =>[signal: VPB w=1]]']]
X__093__29 VPWR _049_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X30 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: a_1139_297# w=1]]', 'g: [connection X30/g =>[signal: B1 w=1]]', 's: [connection X30/s =>[signal: a_109_297# w=1]]', 'b: [connection X30/b =>[signal: VPB w=1]]']]
X__093__30 _093__a_1139_297# _065_ _093__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X31 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: Y w=1]]', 'g: [connection X31/g =>[signal: C1 w=1]]', 's: [connection X31/s =>[signal: VGND w=1]]', 'b: [connection X31/b =>[signal: VNB w=1]]']]
X__093__31 _066_ _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: a_109_297# w=1]]', 'g: [connection X32/g =>[signal: A3 w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X__093__32 _093__a_109_297# _049_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: a_445_47# w=1]]', 'g: [connection X33/g =>[signal: A1 w=1]]', 's: [connection X33/s =>[signal: Y w=1]]', 'b: [connection X33/b =>[signal: VNB w=1]]']]
X__093__33 _093__a_445_47# _048_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_445_47# w=1]]', 'g: [connection X34/g =>[signal: A2 w=1]]', 's: [connection X34/s =>[signal: a_27_47# w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X__093__34 _093__a_445_47# r_Clock_Count[7] _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X35 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VGND w=1]]', 'g: [connection X35/g =>[signal: B1 w=1]]', 's: [connection X35/s =>[signal: Y w=1]]', 'b: [connection X35/b =>[signal: VNB w=1]]']]
X__093__35 VGND _065_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X36 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: a_109_297# w=1]]', 'g: [connection X36/g =>[signal: A3 w=1]]', 's: [connection X36/s =>[signal: VPWR w=1]]', 'b: [connection X36/b =>[signal: VPB w=1]]']]
X__093__36 _093__a_109_297# _049_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: a_109_297# w=1]]', 'g: [connection X37/g =>[signal: B1 w=1]]', 's: [connection X37/s =>[signal: a_1139_297# w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X__093__37 _093__a_109_297# _065_ _093__a_1139_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: a_445_47# w=1]]', 'g: [connection X38/g =>[signal: A1 w=1]]', 's: [connection X38/s =>[signal: Y w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X__093__38 _093__a_445_47# _048_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: C1 w=1]]', 's: [connection X39/s =>[signal: Y w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X__093__39 VGND _051_ _066_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _094_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__094__0 VPWR r_Clock_Count[0] _094__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__094__1 _094__a_76_199# _066_ _094__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__094__2 _094__a_535_374# _094__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__094__3 VPWR r_Clock_Count[0] _094__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__094__4 _094__a_76_199# _052_ _094__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__094__5 _094__a_218_47# _052_ _094__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__094__6 _094__a_218_374# _066_ _094__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__094__7 _067_ _094__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__094__8 _067_ _094__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__094__9 VGND r_Clock_Count[0] _094__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__094__10 VGND r_Clock_Count[0] _094__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__094__11 _094__a_439_47# _094__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _095_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__095__0 VGND _067_ _095__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__095__1 _001_ _095__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__095__2 _001_ _095__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__095__3 VPWR _067_ _095__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _096_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__096__0 _096__a_150_297# r_Clock_Count[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__096__1 VGND _096__a_68_297# _068_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__096__2 VGND r_Clock_Count[1] _096__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__096__3 _096__a_68_297# r_Clock_Count[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__096__4 _096__a_68_297# r_Clock_Count[1] _096__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__096__5 VPWR _096__a_68_297# _068_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _097_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__097__0 _069_ r_Clock_Count[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__097__1 VPWR r_Clock_Count[1] _069_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__097__2 VGND r_Clock_Count[1] _097__a_113_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__097__3 _097__a_113_47# r_Clock_Count[0] _069_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _098_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__098__0 _098__a_93_21# _052_ _098__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__098__1 _002_ _098__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__098__2 _098__a_250_297# r_Clock_Count[1] _098__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__098__3 _098__a_256_47# _068_ _098__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__098__4 _002_ _098__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__098__5 VGND _069_ _098__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__098__6 _098__a_93_21# r_Clock_Count[1] _098__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__098__7 VPWR _066_ _098__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__098__8 _098__a_346_47# _066_ _098__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__098__9 _098__a_250_297# _068_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__098__10 VPWR _069_ _098__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__098__11 _098__a_584_47# _052_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _099_ with the contents of sky130_fd_sc_hd__a311o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: a_201_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__099__0 VPWR _048_ _099__a_201_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A3 w=1]]', 's: [connection X1/s =>[signal: a_208_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__099__1 VGND _049_ _099__a_208_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_75_199# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__099__2 _099__a_75_199# _065_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_544_297# w=1]]', 'g: [connection X3/g =>[signal: C1 w=1]]', 's: [connection X3/s =>[signal: a_75_199# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__099__3 _099__a_544_297# _051_ _099__a_75_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_201_297# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__099__4 _099__a_201_297# r_Clock_Count[7] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_75_199# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__099__5 _070_ _099__a_75_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_208_47# w=1]]', 'g: [connection X6/g =>[signal: A2 w=1]]', 's: [connection X6/s =>[signal: a_315_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__099__6 _099__a_208_47# r_Clock_Count[7] _099__a_315_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_201_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__099__7 VPWR _049_ _099__a_201_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: a_75_199# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__099__8 VGND _051_ _099__a_75_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_75_199# w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__099__9 _070_ _099__a_75_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_315_47# w=1]]', 'g: [connection X10/g =>[signal: A1 w=1]]', 's: [connection X10/s =>[signal: a_75_199# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__099__10 _099__a_315_47# _048_ _099__a_75_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_201_297# w=1]]', 'g: [connection X11/g =>[signal: B1 w=1]]', 's: [connection X11/s =>[signal: a_544_297# w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__099__11 _099__a_201_297# _065_ _099__a_544_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _100_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__100__0 _100__a_109_297# _070_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__100__1 _071_ _070_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__100__2 VGND _069_ _071_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__100__3 _071_ _069_ _100__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _101_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__101__0 _101__a_181_47# r_Clock_Count[2] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__101__1 _101__a_27_47# r_Clock_Count[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__101__2 VPWR r_Clock_Count[1] _101__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__101__3 VPWR _101__a_27_47# _072_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__101__4 _101__a_109_47# r_Clock_Count[1] _101__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__101__5 _101__a_27_47# r_Clock_Count[0] _101__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__101__6 VGND _101__a_27_47# _072_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__101__7 _101__a_27_47# r_Clock_Count[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _102_ with the contents of sky130_fd_sc_hd__o21bai_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: a_297_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__102__0 VGND _070_ _102__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: a_105_352# w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__102__1 _073_ _102__a_105_352# _102__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_105_352# w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__102__2 VPWR _102__a_105_352# _073_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__102__3 _102__a_297_47# _072_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_388_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__102__4 _102__a_388_297# _070_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: B1_N w=1]]', 's: [connection X5/s =>[signal: a_105_352# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__102__5 VGND _052_ _102__a_105_352# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_105_352# w=1]]', 'g: [connection X6/g =>[signal: B1_N w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__102__6 _102__a_105_352# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A2 w=1]]', 's: [connection X7/s =>[signal: a_388_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__102__7 _073_ _072_ _102__a_388_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _103_ with the contents of sky130_fd_sc_hd__o21a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_382_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__103__0 _103__a_382_297# r_Clock_Count[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__103__1 VGND r_Clock_Count[2] _103__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__103__2 _103__a_79_21# _073_ _103__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_79_21# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__103__3 _003_ _103__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__103__4 _103__a_297_47# _071_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_79_21# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_382_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__103__5 _103__a_79_21# _071_ _103__a_382_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_79_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__103__6 VPWR _073_ _103__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__103__7 _003_ _103__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _104_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__104__0 VGND _104__a_59_75# _074_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__104__1 VPWR _066_ _104__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__104__2 _104__a_59_75# _066_ _104__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__104__3 _104__a_59_75# _072_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__104__4 _104__a_145_75# _072_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__104__5 VPWR _104__a_59_75# _074_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _105_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__105__0 VPWR r_Clock_Count[3] _105__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__105__1 _105__a_76_199# _074_ _105__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__105__2 _105__a_535_374# _105__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__105__3 VPWR r_Clock_Count[3] _105__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__105__4 _105__a_76_199# _073_ _105__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__105__5 _105__a_218_47# _073_ _105__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__105__6 _105__a_218_374# _074_ _105__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__105__7 _075_ _105__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__105__8 _075_ _105__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__105__9 VGND r_Clock_Count[3] _105__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__105__10 VGND r_Clock_Count[3] _105__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__105__11 _105__a_439_47# _105__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _106_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__106__0 VGND _075_ _106__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__106__1 _004_ _106__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__106__2 _004_ _106__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__106__3 VPWR _075_ _106__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _107_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__107__0 _107__a_181_47# _072_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__107__1 _107__a_27_47# r_Clock_Count[4] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__107__2 VPWR r_Clock_Count[3] _107__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__107__3 VPWR _107__a_27_47# _076_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__107__4 _107__a_109_47# r_Clock_Count[3] _107__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__107__5 _107__a_27_47# r_Clock_Count[4] _107__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__107__6 VGND _107__a_27_47# _076_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__107__7 _107__a_27_47# _072_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _108_ with the contents of sky130_fd_sc_hd__o21bai_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: a_297_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__108__0 VGND _070_ _108__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: a_105_352# w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__108__1 _077_ _108__a_105_352# _108__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_105_352# w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__108__2 VPWR _108__a_105_352# _077_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__108__3 _108__a_297_47# _076_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_388_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__108__4 _108__a_388_297# _070_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: B1_N w=1]]', 's: [connection X5/s =>[signal: a_105_352# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__108__5 VGND _052_ _108__a_105_352# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_105_352# w=1]]', 'g: [connection X6/g =>[signal: B1_N w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__108__6 _108__a_105_352# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A2 w=1]]', 's: [connection X7/s =>[signal: a_388_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__108__7 _077_ _076_ _108__a_388_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _109_ with the contents of sky130_fd_sc_hd__a31o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_80_21# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__109__0 _109__a_80_21# r_Clock_Count[4] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__109__1 _078_ _109__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_209_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_303_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__109__2 _109__a_209_47# _066_ _109__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_80_21# w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__109__3 _078_ _109__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_303_47# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_80_21# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__109__4 _109__a_303_47# r_Clock_Count[3] _109__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_209_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__109__5 VPWR r_Clock_Count[3] _109__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_209_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__109__6 _109__a_209_297# r_Clock_Count[4] _109__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_209_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__109__7 VGND _072_ _109__a_209_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_209_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__109__8 _109__a_209_297# _066_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_209_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__109__9 VPWR _072_ _109__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _110_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__110__0 VGND _110__a_59_75# _079_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__110__1 VPWR _077_ _110__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__110__2 _110__a_59_75# _077_ _110__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__110__3 _110__a_59_75# _078_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__110__4 _110__a_145_75# _078_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__110__5 VPWR _110__a_59_75# _079_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _111_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__111__0 VGND _079_ _111__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__111__1 _005_ _111__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__111__2 _005_ _111__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__111__3 VPWR _079_ _111__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _112_ with the contents of sky130_fd_sc_hd__and3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_209_311# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: a_296_53# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__112__0 _112__a_209_311# _112__a_109_93# _112__a_296_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_209_311# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__112__1 VGND _112__a_209_311# _022_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: a_109_93# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__112__2 VGND r_Clock_Count[5] _112__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_209_311# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__112__3 VPWR _112__a_209_311# _022_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: a_109_93# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__112__4 VPWR r_Clock_Count[5] _112__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_368_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__112__5 _112__a_368_53# _076_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_209_311# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__112__6 VPWR _066_ _112__a_209_311# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_209_311# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__112__7 _112__a_209_311# _076_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_296_53# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_368_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__112__8 _112__a_296_53# _066_ _112__a_368_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_209_311# w=1]]', 'g: [connection X9/g =>[signal: a_109_93# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__112__9 _112__a_209_311# _112__a_109_93# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _113_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__113__0 _113__a_384_47# _077_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__113__1 _006_ _113__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__113__2 _113__a_81_21# _022_ _113__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__113__3 VGND _022_ _113__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__113__4 _113__a_299_297# r_Clock_Count[5] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__113__5 VPWR _077_ _113__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__113__6 _006_ _113__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__113__7 _113__a_81_21# r_Clock_Count[5] _113__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _114_ with the contents of sky130_fd_sc_hd__a31oi_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__114__0 _114__a_109_297# _070_ _023_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_181_47# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__114__1 _114__a_181_47# _048_ _023_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: A1 w=1]]', 's: [connection X2/s =>[signal: a_109_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__114__2 VPWR _048_ _114__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_109_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_181_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__114__3 _114__a_109_47# r_Clock_Count[5] _114__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__114__4 _023_ _070_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__114__5 VGND _076_ _114__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: A3 w=1]]', 's: [connection X6/s =>[signal: a_109_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__114__6 VPWR _076_ _114__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_109_297# w=1]]', 'g: [connection X7/g =>[signal: A2 w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__114__7 _114__a_109_297# r_Clock_Count[5] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _115_ with the contents of sky130_fd_sc_hd__a31o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_80_21# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__115__0 _115__a_80_21# _048_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__115__1 _024_ _115__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_209_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_303_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__115__2 _115__a_209_47# _066_ _115__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_80_21# w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__115__3 _024_ _115__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_303_47# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_80_21# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__115__4 _115__a_303_47# r_Clock_Count[5] _115__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_209_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__115__5 VPWR r_Clock_Count[5] _115__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_209_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__115__6 _115__a_209_297# _048_ _115__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_209_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__115__7 VGND _076_ _115__a_209_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_209_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__115__8 _115__a_209_297# _066_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_209_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__115__9 VPWR _076_ _115__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _116_ with the contents of sky130_fd_sc_hd__o21a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_382_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__116__0 _116__a_382_297# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__116__1 VGND _052_ _116__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__116__2 _116__a_79_21# _024_ _116__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_79_21# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__116__3 _007_ _116__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__116__4 _116__a_297_47# _023_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_79_21# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_382_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__116__5 _116__a_79_21# _023_ _116__a_382_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_79_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__116__6 VPWR _024_ _116__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__116__7 _007_ _116__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _118_ with the contents of sky130_fd_sc_hd__a41o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__118__0 VGND r_Clock_Count[7] _118__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A4 w=1]]', 's: [connection X1/s =>[signal: a_297_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__118__1 VPWR _076_ _118__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__118__2 _118__a_79_21# r_Clock_Count[7] _118__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_297_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__118__3 VPWR r_Clock_Count[5] _118__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_297# w=1]]', 'g: [connection X4/g =>[signal: A3 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__118__4 _118__a_297_297# _066_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_297_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__118__5 _118__a_297_297# _048_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_465_47# w=1]]', 'g: [connection X6/g =>[signal: A3 w=1]]', 's: [connection X6/s =>[signal: a_561_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__118__6 _118__a_465_47# _066_ _118__a_561_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_561_47# w=1]]', 'g: [connection X7/g =>[signal: A4 w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__118__7 _118__a_561_47# _076_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_465_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__118__8 _118__a_381_47# r_Clock_Count[5] _118__a_465_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_79_21# w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__118__9 _026_ _118__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_79_21# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__118__10 _026_ _118__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_79_21# w=1]]', 'g: [connection X11/g =>[signal: A1 w=1]]', 's: [connection X11/s =>[signal: a_381_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__118__11 _118__a_79_21# _048_ _118__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _119_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__119__0 _119__a_253_47# _025_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__119__1 VPWR _052_ _119__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__119__2 _008_ _119__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__119__3 _008_ _119__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__119__4 VGND _052_ _119__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__119__5 _119__a_103_199# _026_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__119__6 _119__a_253_47# _026_ _119__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__119__7 VGND _023_ _119__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__119__8 _119__a_253_297# _025_ _119__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__119__9 _119__a_337_297# _023_ _119__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _121_ with the contents of sky130_fd_sc_hd__mux4_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_277_47# w=1]]', 'g: [connection X0/g =>[signal: S1 w=1]]', 's: [connection X0/s =>[signal: a_1478_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__121__0 _121__a_277_47# r_Bit_Index[1] _121__a_1478_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_757_363# w=1]]', 'g: [connection X1/g =>[signal: S0 w=1]]', 's: [connection X1/s =>[signal: a_750_97# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__121__1 _121__a_757_363# r_Bit_Index[0] _121__a_750_97# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_668_97# w=1]]', 'g: [connection X2/g =>[signal: S0 w=1]]', 's: [connection X2/s =>[signal: a_750_97# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__121__2 _121__a_668_97# r_Bit_Index[0] _121__a_750_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_750_97# w=1]]', 'g: [connection X3/g =>[signal: S1 w=1]]', 's: [connection X3/s =>[signal: a_1478_413# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__121__3 _121__a_750_97# r_Bit_Index[1] _121__a_1478_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_757_363# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__121__4 VPWR r_TX_Data[6] _121__a_757_363# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_277_47# w=1]]', 'g: [connection X5/g =>[signal: S0 w=1]]', 's: [connection X5/s =>[signal: a_27_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__121__5 _121__a_277_47# r_Bit_Index[0] _121__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1478_413# w=1]]', 'g: [connection X6/g =>[signal: a_1290_413# w=1]]', 's: [connection X6/s =>[signal: a_277_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__121__6 _121__a_1478_413# _121__a_1290_413# _121__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_47# w=1]]', 'g: [connection X7/g =>[signal: S0 w=1]]', 's: [connection X7/s =>[signal: a_193_413# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__121__7 _121__a_277_47# r_Bit_Index[0] _121__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_923_363# w=1]]', 'g: [connection X8/g =>[signal: A3 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__121__8 _121__a_923_363# r_TX_Data[7] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_1478_413# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__121__9 VPWR _121__a_1478_413# _028_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_413# w=1]]', 'g: [connection X10/g =>[signal: a_247_21# w=1]]', 's: [connection X10/s =>[signal: a_277_47# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__121__10 _121__a_27_413# _121__a_247_21# _121__a_277_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_668_97# w=1]]', 'g: [connection X11/g =>[signal: A3 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__121__11 _121__a_668_97# r_TX_Data[7] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VGND w=1]]', 'g: [connection X12/g =>[signal: a_1478_413# w=1]]', 's: [connection X12/s =>[signal: X w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__121__12 VGND _121__a_1478_413# _028_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_193_47# w=1]]', 'g: [connection X13/g =>[signal: a_247_21# w=1]]', 's: [connection X13/s =>[signal: a_277_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__121__13 _121__a_193_47# _121__a_247_21# _121__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_247_21# w=1]]', 'g: [connection X14/g =>[signal: S0 w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__121__14 _121__a_247_21# r_Bit_Index[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_27_413# w=1]]', 'g: [connection X15/g =>[signal: A1 w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__121__15 _121__a_27_413# r_TX_Data[5] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: A0 w=1]]', 's: [connection X16/s =>[signal: a_193_413# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__121__16 VPWR r_TX_Data[4] _121__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_1478_413# w=1]]', 'g: [connection X17/g =>[signal: a_1290_413# w=1]]', 's: [connection X17/s =>[signal: a_750_97# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__121__17 _121__a_1478_413# _121__a_1290_413# _121__a_750_97# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_247_21# w=1]]', 'g: [connection X18/g =>[signal: S0 w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__121__18 _121__a_247_21# r_Bit_Index[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_750_97# w=1]]', 'g: [connection X19/g =>[signal: a_247_21# w=1]]', 's: [connection X19/s =>[signal: a_923_363# w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__121__19 _121__a_750_97# _121__a_247_21# _121__a_923_363# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: S1 w=1]]', 's: [connection X20/s =>[signal: a_1290_413# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__121__20 VPWR r_Bit_Index[1] _121__a_1290_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: A0 w=1]]', 's: [connection X21/s =>[signal: a_193_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__121__21 VGND r_TX_Data[4] _121__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_27_47# w=1]]', 'g: [connection X22/g =>[signal: A1 w=1]]', 's: [connection X22/s =>[signal: VGND w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__121__22 _121__a_27_47# r_TX_Data[5] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: A2 w=1]]', 's: [connection X23/s =>[signal: a_834_97# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__121__23 VGND r_TX_Data[6] _121__a_834_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_750_97# w=1]]', 'g: [connection X24/g =>[signal: a_247_21# w=1]]', 's: [connection X24/s =>[signal: a_834_97# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__121__24 _121__a_750_97# _121__a_247_21# _121__a_834_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: S1 w=1]]', 's: [connection X25/s =>[signal: a_1290_413# w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__121__25 VGND r_Bit_Index[1] _121__a_1290_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _122_ with the contents of sky130_fd_sc_hd__mux4_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_277_47# w=1]]', 'g: [connection X0/g =>[signal: S1 w=1]]', 's: [connection X0/s =>[signal: a_1478_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__122__0 _122__a_277_47# r_Bit_Index[1] _122__a_1478_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_757_363# w=1]]', 'g: [connection X1/g =>[signal: S0 w=1]]', 's: [connection X1/s =>[signal: a_750_97# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__122__1 _122__a_757_363# r_Bit_Index[0] _122__a_750_97# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_668_97# w=1]]', 'g: [connection X2/g =>[signal: S0 w=1]]', 's: [connection X2/s =>[signal: a_750_97# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__122__2 _122__a_668_97# r_Bit_Index[0] _122__a_750_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_750_97# w=1]]', 'g: [connection X3/g =>[signal: S1 w=1]]', 's: [connection X3/s =>[signal: a_1478_413# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__122__3 _122__a_750_97# r_Bit_Index[1] _122__a_1478_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_757_363# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__122__4 VPWR r_TX_Data[2] _122__a_757_363# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_277_47# w=1]]', 'g: [connection X5/g =>[signal: S0 w=1]]', 's: [connection X5/s =>[signal: a_27_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__122__5 _122__a_277_47# r_Bit_Index[0] _122__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1478_413# w=1]]', 'g: [connection X6/g =>[signal: a_1290_413# w=1]]', 's: [connection X6/s =>[signal: a_277_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__122__6 _122__a_1478_413# _122__a_1290_413# _122__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_47# w=1]]', 'g: [connection X7/g =>[signal: S0 w=1]]', 's: [connection X7/s =>[signal: a_193_413# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__122__7 _122__a_277_47# r_Bit_Index[0] _122__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_923_363# w=1]]', 'g: [connection X8/g =>[signal: A3 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__122__8 _122__a_923_363# r_TX_Data[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_1478_413# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__122__9 VPWR _122__a_1478_413# _029_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_413# w=1]]', 'g: [connection X10/g =>[signal: a_247_21# w=1]]', 's: [connection X10/s =>[signal: a_277_47# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__122__10 _122__a_27_413# _122__a_247_21# _122__a_277_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_668_97# w=1]]', 'g: [connection X11/g =>[signal: A3 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__122__11 _122__a_668_97# r_TX_Data[3] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VGND w=1]]', 'g: [connection X12/g =>[signal: a_1478_413# w=1]]', 's: [connection X12/s =>[signal: X w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__122__12 VGND _122__a_1478_413# _029_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_193_47# w=1]]', 'g: [connection X13/g =>[signal: a_247_21# w=1]]', 's: [connection X13/s =>[signal: a_277_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__122__13 _122__a_193_47# _122__a_247_21# _122__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_247_21# w=1]]', 'g: [connection X14/g =>[signal: S0 w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__122__14 _122__a_247_21# r_Bit_Index[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_27_413# w=1]]', 'g: [connection X15/g =>[signal: A1 w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__122__15 _122__a_27_413# r_TX_Data[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: A0 w=1]]', 's: [connection X16/s =>[signal: a_193_413# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__122__16 VPWR r_TX_Data[0] _122__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_1478_413# w=1]]', 'g: [connection X17/g =>[signal: a_1290_413# w=1]]', 's: [connection X17/s =>[signal: a_750_97# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__122__17 _122__a_1478_413# _122__a_1290_413# _122__a_750_97# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_247_21# w=1]]', 'g: [connection X18/g =>[signal: S0 w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__122__18 _122__a_247_21# r_Bit_Index[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_750_97# w=1]]', 'g: [connection X19/g =>[signal: a_247_21# w=1]]', 's: [connection X19/s =>[signal: a_923_363# w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__122__19 _122__a_750_97# _122__a_247_21# _122__a_923_363# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: S1 w=1]]', 's: [connection X20/s =>[signal: a_1290_413# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__122__20 VPWR r_Bit_Index[1] _122__a_1290_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: A0 w=1]]', 's: [connection X21/s =>[signal: a_193_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__122__21 VGND r_TX_Data[0] _122__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_27_47# w=1]]', 'g: [connection X22/g =>[signal: A1 w=1]]', 's: [connection X22/s =>[signal: VGND w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__122__22 _122__a_27_47# r_TX_Data[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: A2 w=1]]', 's: [connection X23/s =>[signal: a_834_97# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__122__23 VGND r_TX_Data[2] _122__a_834_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_750_97# w=1]]', 'g: [connection X24/g =>[signal: a_247_21# w=1]]', 's: [connection X24/s =>[signal: a_834_97# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__122__24 _122__a_750_97# _122__a_247_21# _122__a_834_97# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: S1 w=1]]', 's: [connection X25/s =>[signal: a_1290_413# w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__122__25 VGND r_Bit_Index[1] _122__a_1290_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _123_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__123__0 _123__a_150_297# r_Bit_Index[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__123__1 VGND _123__a_68_297# _030_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__123__2 VGND _029_ _123__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__123__3 _123__a_68_297# r_Bit_Index[2] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__123__4 _123__a_68_297# _029_ _123__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__123__5 VPWR _123__a_68_297# _030_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _124_ with the contents of sky130_fd_sc_hd__nor3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__124__0 _031_ _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: C_N w=1]]', 's: [connection X1/s =>[signal: a_91_199# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__124__1 VPWR r_SM_Main[1] _124__a_91_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_161_297# w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_245_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__124__2 _124__a_161_297# r_SM_Main[0] _124__a_245_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: C_N w=1]]', 's: [connection X3/s =>[signal: a_91_199# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__124__3 VGND r_SM_Main[1] _124__a_91_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: a_91_199# w=1]]', 's: [connection X4/s =>[signal: a_161_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__124__4 _031_ _124__a_91_199# _124__a_161_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_245_297# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__124__5 _124__a_245_297# _051_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: Y w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__124__6 VGND r_SM_Main[0] _031_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: a_91_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__124__7 _031_ _124__a_91_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _125_ with the contents of sky130_fd_sc_hd__o211a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: C1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__125__0 VPWR _031_ _125__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_47# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__125__1 _125__a_215_47# _027_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_215_47# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_510_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__125__2 _125__a_215_47# _030_ _125__a_510_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_297# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_79_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__125__3 _125__a_297_297# _028_ _125__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_297_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__125__4 VPWR _027_ _125__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_215_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__125__5 VGND _028_ _125__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_79_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__125__6 _032_ _125__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__125__7 _032_ _125__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_510_47# w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: a_79_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__125__8 _125__a_510_47# _031_ _125__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_79_21# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__125__9 _125__a_79_21# _030_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _126_ with the contents of sky130_fd_sc_hd__a2111o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: D1 w=1]]', 's: [connection X0/s =>[signal: a_85_193# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__126__0 VGND _032_ _126__a_85_193# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_85_193# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__126__1 _009_ _126__a_85_193# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_516_297# w=1]]', 'g: [connection X2/g =>[signal: A1 w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__126__2 _126__a_516_297# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_414_297# w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_516_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__126__3 _126__a_414_297# _058_ _126__a_516_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_660_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__126__4 _126__a_660_47# net13 VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_516_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__126__5 VPWR net13 _126__a_516_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_85_193# w=1]]', 'g: [connection X6/g =>[signal: C1 w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__126__6 _126__a_85_193# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_85_193# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__126__7 _009_ _126__a_85_193# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B1 w=1]]', 's: [connection X8/s =>[signal: a_85_193# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__126__8 VGND _058_ _126__a_85_193# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_85_193# w=1]]', 'g: [connection X9/g =>[signal: A1 w=1]]', 's: [connection X9/s =>[signal: a_660_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__126__9 _126__a_85_193# _052_ _126__a_660_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_85_193# w=1]]', 'g: [connection X10/g =>[signal: D1 w=1]]', 's: [connection X10/s =>[signal: a_334_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__126__10 _126__a_85_193# _032_ _126__a_334_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_334_297# w=1]]', 'g: [connection X11/g =>[signal: C1 w=1]]', 's: [connection X11/s =>[signal: a_414_297# w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__126__11 _126__a_334_297# _061_ _126__a_414_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _127_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__127__0 _127__a_199_47# _031_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__127__1 _127__a_113_297# _057_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__127__2 _033_ _058_ _127__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__127__3 VGND _058_ _033_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__127__4 VPWR _031_ _127__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__127__5 _033_ _057_ _127__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _128_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__128__0 VPWR r_Bit_Index[0] _128__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__128__1 _128__a_76_199# _054_ _128__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__128__2 _128__a_535_374# _128__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__128__3 VPWR r_Bit_Index[0] _128__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__128__4 _128__a_76_199# _033_ _128__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__128__5 _128__a_218_47# _033_ _128__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__128__6 _128__a_218_374# _054_ _128__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__128__7 _034_ _128__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__128__8 _034_ _128__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__128__9 VGND r_Bit_Index[0] _128__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__128__10 VGND r_Bit_Index[0] _128__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__128__11 _128__a_439_47# _128__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _129_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__129__0 VGND _034_ _129__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__129__1 _010_ _129__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__129__2 _010_ _129__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__129__3 VPWR _034_ _129__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _130_ with the contents of sky130_fd_sc_hd__a41o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__130__0 VGND _058_ _130__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A4 w=1]]', 's: [connection X1/s =>[signal: a_297_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__130__1 VPWR _031_ _130__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__130__2 _130__a_79_21# _058_ _130__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_297_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__130__3 VPWR r_Clock_Count[7] _130__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_297# w=1]]', 'g: [connection X4/g =>[signal: A3 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__130__4 _130__a_297_297# _049_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_297_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__130__5 _130__a_297_297# _048_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_465_47# w=1]]', 'g: [connection X6/g =>[signal: A3 w=1]]', 's: [connection X6/s =>[signal: a_561_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__130__6 _130__a_465_47# _049_ _130__a_561_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_561_47# w=1]]', 'g: [connection X7/g =>[signal: A4 w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__130__7 _130__a_561_47# _031_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_465_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__130__8 _130__a_381_47# r_Clock_Count[7] _130__a_465_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_79_21# w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__130__9 _035_ _130__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_79_21# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__130__10 _035_ _130__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_79_21# w=1]]', 'g: [connection X11/g =>[signal: A1 w=1]]', 's: [connection X11/s =>[signal: a_381_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__130__11 _130__a_79_21# _048_ _130__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _131_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__131__0 _131__a_181_47# _035_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__131__1 _131__a_27_47# r_Bit_Index[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__131__2 VPWR r_Bit_Index[0] _131__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__131__3 VPWR _131__a_27_47# _036_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__131__4 _131__a_109_47# r_Bit_Index[0] _131__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__131__5 _131__a_27_47# r_Bit_Index[1] _131__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__131__6 VGND _131__a_27_47# _036_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__131__7 _131__a_27_47# _035_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _132_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__132__0 _132__a_199_47# _035_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__132__1 _132__a_113_297# r_Bit_Index[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__132__2 _037_ r_Bit_Index[1] _132__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__132__3 VGND r_Bit_Index[1] _037_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__132__4 VPWR _035_ _132__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__132__5 _037_ r_Bit_Index[0] _132__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _133_ with the contents of sky130_fd_sc_hd__nor3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__133__0 _011_ _058_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__133__1 VGND _036_ _011_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_193_297# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__133__2 _133__a_193_297# _058_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__133__3 _011_ _037_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_109_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__133__4 _011_ _037_ _133__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_193_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__133__5 _133__a_109_297# _036_ _133__a_193_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _134_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__134__0 _134__a_109_297# _053_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__134__1 _038_ _053_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__134__2 VGND _055_ _038_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__134__3 _038_ _055_ _134__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _135_ with the contents of sky130_fd_sc_hd__o22a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_292_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__135__0 VPWR _038_ _135__a_292_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_47# w=1]]', 'g: [connection X1/g =>[signal: B1 w=1]]', 's: [connection X1/s =>[signal: a_78_199# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__135__1 _135__a_215_47# _038_ _135__a_78_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_78_199# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__135__2 _012_ _135__a_78_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_292_297# w=1]]', 'g: [connection X3/g =>[signal: B2 w=1]]', 's: [connection X3/s =>[signal: a_78_199# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__135__3 _135__a_292_297# _033_ _135__a_78_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_215_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__135__4 VGND r_Bit_Index[2] _135__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_215_47# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__135__5 _135__a_215_47# _036_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_78_199# w=1]]', 'g: [connection X6/g =>[signal: A2 w=1]]', 's: [connection X6/s =>[signal: a_493_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__135__6 _135__a_78_199# _036_ _135__a_493_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_493_297# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__135__7 _135__a_493_297# r_Bit_Index[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_78_199# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__135__8 _012_ _135__a_78_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_78_199# w=1]]', 'g: [connection X9/g =>[signal: B2 w=1]]', 's: [connection X9/s =>[signal: a_215_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__135__9 _135__a_78_199# _033_ _135__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _136_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__136__0 VPWR _059_ _136__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__136__1 _136__a_76_199# net2 _136__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__136__2 _136__a_535_374# _136__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__136__3 VPWR _059_ _136__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__136__4 _136__a_76_199# r_TX_Data[0] _136__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__136__5 _136__a_218_47# r_TX_Data[0] _136__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__136__6 _136__a_218_374# net2 _136__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__136__7 _039_ _136__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__136__8 _039_ _136__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__136__9 VGND _059_ _136__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__136__10 VGND _059_ _136__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__136__11 _136__a_439_47# _136__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _137_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__137__0 VGND _039_ _137__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__137__1 _013_ _137__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__137__2 _013_ _137__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__137__3 VPWR _039_ _137__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _138_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__138__0 VPWR _059_ _138__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__138__1 _138__a_76_199# net3 _138__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__138__2 _138__a_535_374# _138__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__138__3 VPWR _059_ _138__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__138__4 _138__a_76_199# r_TX_Data[1] _138__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__138__5 _138__a_218_47# r_TX_Data[1] _138__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__138__6 _138__a_218_374# net3 _138__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__138__7 _040_ _138__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__138__8 _040_ _138__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__138__9 VGND _059_ _138__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__138__10 VGND _059_ _138__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__138__11 _138__a_439_47# _138__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _139_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__139__0 VGND _040_ _139__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__139__1 _014_ _139__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__139__2 _014_ _139__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__139__3 VPWR _040_ _139__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _140_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__140__0 VPWR _059_ _140__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__140__1 _140__a_76_199# net4 _140__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__140__2 _140__a_535_374# _140__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__140__3 VPWR _059_ _140__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__140__4 _140__a_76_199# r_TX_Data[2] _140__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__140__5 _140__a_218_47# r_TX_Data[2] _140__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__140__6 _140__a_218_374# net4 _140__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__140__7 _041_ _140__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__140__8 _041_ _140__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__140__9 VGND _059_ _140__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__140__10 VGND _059_ _140__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__140__11 _140__a_439_47# _140__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _141_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__141__0 VGND _041_ _141__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__141__1 _015_ _141__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__141__2 _015_ _141__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__141__3 VPWR _041_ _141__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _142_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__142__0 VPWR _059_ _142__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__142__1 _142__a_76_199# net5 _142__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__142__2 _142__a_535_374# _142__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__142__3 VPWR _059_ _142__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__142__4 _142__a_76_199# r_TX_Data[3] _142__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__142__5 _142__a_218_47# r_TX_Data[3] _142__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__142__6 _142__a_218_374# net5 _142__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__142__7 _042_ _142__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__142__8 _042_ _142__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__142__9 VGND _059_ _142__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__142__10 VGND _059_ _142__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__142__11 _142__a_439_47# _142__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _143_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__143__0 VGND _042_ _143__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__143__1 _016_ _143__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__143__2 _016_ _143__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__143__3 VPWR _042_ _143__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _144_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__144__0 VPWR _059_ _144__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__144__1 _144__a_76_199# net6 _144__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__144__2 _144__a_535_374# _144__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__144__3 VPWR _059_ _144__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__144__4 _144__a_76_199# r_TX_Data[4] _144__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__144__5 _144__a_218_47# r_TX_Data[4] _144__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__144__6 _144__a_218_374# net6 _144__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__144__7 _043_ _144__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__144__8 _043_ _144__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__144__9 VGND _059_ _144__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__144__10 VGND _059_ _144__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__144__11 _144__a_439_47# _144__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _145_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__145__0 VGND _043_ _145__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__145__1 _017_ _145__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__145__2 _017_ _145__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__145__3 VPWR _043_ _145__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _146_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__146__0 VPWR _059_ _146__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__146__1 _146__a_76_199# net7 _146__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__146__2 _146__a_535_374# _146__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__146__3 VPWR _059_ _146__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__146__4 _146__a_76_199# r_TX_Data[5] _146__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__146__5 _146__a_218_47# r_TX_Data[5] _146__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__146__6 _146__a_218_374# net7 _146__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__146__7 _044_ _146__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__146__8 _044_ _146__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__146__9 VGND _059_ _146__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__146__10 VGND _059_ _146__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__146__11 _146__a_439_47# _146__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _147_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__147__0 VGND _044_ _147__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__147__1 _018_ _147__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__147__2 _018_ _147__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__147__3 VPWR _044_ _147__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _148_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__148__0 VPWR _059_ _148__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__148__1 _148__a_76_199# net8 _148__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__148__2 _148__a_535_374# _148__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__148__3 VPWR _059_ _148__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__148__4 _148__a_76_199# r_TX_Data[6] _148__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__148__5 _148__a_218_47# r_TX_Data[6] _148__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__148__6 _148__a_218_374# net8 _148__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__148__7 _045_ _148__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__148__8 _045_ _148__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__148__9 VGND _059_ _148__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__148__10 VGND _059_ _148__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__148__11 _148__a_439_47# _148__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _149_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__149__0 VGND _045_ _149__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__149__1 _019_ _149__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__149__2 _019_ _149__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__149__3 VPWR _045_ _149__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _150_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__150__0 VPWR _059_ _150__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__150__1 _150__a_76_199# net9 _150__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__150__2 _150__a_535_374# _150__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__150__3 VPWR _059_ _150__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__150__4 _150__a_76_199# r_TX_Data[7] _150__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__150__5 _150__a_218_47# r_TX_Data[7] _150__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__150__6 _150__a_218_374# net9 _150__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__150__7 _046_ _150__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__150__8 _046_ _150__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__150__9 VGND _059_ _150__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__150__10 VGND _059_ _150__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__150__11 _150__a_439_47# _150__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _151_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__151__0 VGND _046_ _151__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__151__1 _020_ _151__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__151__2 _020_ _151__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__151__3 VPWR _046_ _151__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _153_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__153__0 _153__a_253_47# _065_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__153__1 VPWR net12 _153__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__153__2 _021_ _153__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__153__3 _021_ _153__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__153__4 VGND net12 _153__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__153__5 _153__a_103_199# _047_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__153__6 _153__a_253_47# _047_ _153__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__153__7 VGND _082_ _153__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__153__8 _153__a_253_297# _065_ _153__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__153__9 _153__a_337_297# _082_ _153__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _154_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__154__0 _048_ _154__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__154__1 _154__a_27_47# r_Clock_Count[6] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__154__2 VGND _154__a_27_47# _048_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__154__3 _048_ _154__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__154__4 VPWR _154__a_27_47# _048_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__154__5 _154__a_27_47# r_Clock_Count[6] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _155_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__155__0 _155__a_384_47# r_Clock_Count[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__155__1 _049_ _155__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__155__2 _155__a_81_21# r_Clock_Count[5] _155__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__155__3 VGND r_Clock_Count[5] _155__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__155__4 _155__a_299_297# r_Clock_Count[4] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__155__5 VPWR r_Clock_Count[3] _155__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__155__6 _049_ _155__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__155__7 _155__a_81_21# r_Clock_Count[4] _155__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _156_ with the contents of sky130_fd_sc_hd__nand3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__156__0 VPWR _048_ _050_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_109_47# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_193_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__156__1 _156__a_109_47# r_Clock_Count[7] _156__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_109_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__156__2 VGND _049_ _156__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_193_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__156__3 _156__a_193_47# _048_ _050_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__156__4 VPWR _049_ _050_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__156__5 _050_ r_Clock_Count[7] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _157_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__157__0 _051_ _157__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__157__1 _157__a_27_47# r_SM_Main[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__157__2 VGND _157__a_27_47# _051_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__157__3 _051_ _157__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__157__4 VPWR _157__a_27_47# _051_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__157__5 _157__a_27_47# r_SM_Main[2] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _158_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__158__0 _052_ _158__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__158__1 _158__a_27_47# _051_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__158__2 VGND _158__a_27_47# _052_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__158__3 _052_ _158__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__158__4 VPWR _158__a_27_47# _052_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__158__5 _158__a_27_47# _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _159_ with the contents of sky130_fd_sc_hd__or3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_215_53# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__159__0 _159__a_215_53# _159__a_109_93# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_215_53# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__159__1 VGND _159__a_215_53# _053_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_215_53# w=1]]', 'g: [connection X2/g =>[signal: a_109_93# w=1]]', 's: [connection X2/s =>[signal: a_297_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__159__2 _159__a_215_53# _159__a_109_93# _159__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_297# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_369_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__159__3 _159__a_297_297# r_SM_Main[0] _159__a_369_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_369_297# w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__159__4 _159__a_369_297# _052_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_215_53# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__159__5 VPWR _159__a_215_53# _053_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_215_53# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__159__6 _159__a_215_53# _052_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: C_N w=1]]', 's: [connection X7/s =>[signal: a_109_93# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__159__7 VGND r_SM_Main[1] _159__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_215_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__159__8 VGND r_SM_Main[0] _159__a_215_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: C_N w=1]]', 's: [connection X9/s =>[signal: a_109_93# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__159__9 VPWR r_SM_Main[1] _159__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _160_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__160__0 _160__a_109_297# _050_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__160__1 _054_ _050_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__160__2 VGND _053_ _054_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__160__3 _054_ _053_ _160__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _161_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__161__0 _161__a_181_47# r_Bit_Index[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__161__1 _161__a_27_47# r_Bit_Index[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__161__2 VPWR r_Bit_Index[1] _161__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__161__3 VPWR _161__a_27_47# _055_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__161__4 _161__a_109_47# r_Bit_Index[1] _161__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__161__5 _161__a_27_47# r_Bit_Index[2] _161__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__161__6 VGND _161__a_27_47# _055_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__161__7 _161__a_27_47# r_Bit_Index[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _163_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__163__0 _163__a_181_47# _049_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__163__1 _163__a_27_47# _048_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__163__2 VPWR r_Clock_Count[7] _163__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__163__3 VPWR _163__a_27_47# _057_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__163__4 _163__a_109_47# r_Clock_Count[7] _163__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__163__5 _163__a_27_47# _048_ _163__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__163__6 VGND _163__a_27_47# _057_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__163__7 _163__a_27_47# _049_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _164_ with the contents of sky130_fd_sc_hd__nor3_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: a_449_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__164__0 _164__a_27_297# r_SM_Main[0] _164__a_449_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__164__1 _058_ _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__164__2 VPWR _051_ _164__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__164__3 VPWR _051_ _164__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_449_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_27_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__164__4 _164__a_449_297# r_SM_Main[0] _164__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__164__5 VGND _051_ _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_449_297# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_27_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__164__6 _164__a_449_297# r_SM_Main[0] _164__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__164__7 _058_ r_SM_Main[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__164__8 _164__a_27_297# _051_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: Y w=1]]', 'g: [connection X9/g =>[signal: B w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__164__9 _058_ r_SM_Main[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_297# w=1]]', 'g: [connection X10/g =>[signal: A w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__164__10 _164__a_27_297# _051_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VGND w=1]]', 'g: [connection X11/g =>[signal: A w=1]]', 's: [connection X11/s =>[signal: Y w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__164__11 VGND _051_ _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VGND w=1]]', 'g: [connection X12/g =>[signal: C w=1]]', 's: [connection X12/s =>[signal: Y w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__164__12 VGND r_SM_Main[1] _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_449_297# w=1]]', 'g: [connection X13/g =>[signal: C w=1]]', 's: [connection X13/s =>[signal: Y w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__164__13 _164__a_449_297# r_SM_Main[1] _058_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: Y w=1]]', 'g: [connection X14/g =>[signal: C w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__164__14 _058_ r_SM_Main[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_27_297# w=1]]', 'g: [connection X15/g =>[signal: B w=1]]', 's: [connection X15/s =>[signal: a_449_297# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__164__15 _164__a_27_297# r_SM_Main[0] _164__a_449_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: Y w=1]]', 'g: [connection X16/g =>[signal: A w=1]]', 's: [connection X16/s =>[signal: VGND w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__164__16 _058_ _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: Y w=1]]', 'g: [connection X17/g =>[signal: B w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__164__17 _058_ r_SM_Main[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: Y w=1]]', 'g: [connection X18/g =>[signal: C w=1]]', 's: [connection X18/s =>[signal: a_449_297# w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__164__18 _058_ r_SM_Main[1] _164__a_449_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: Y w=1]]', 'g: [connection X19/g =>[signal: C w=1]]', 's: [connection X19/s =>[signal: a_449_297# w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__164__19 _058_ r_SM_Main[1] _164__a_449_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_449_297# w=1]]', 'g: [connection X20/g =>[signal: C w=1]]', 's: [connection X20/s =>[signal: Y w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__164__20 _164__a_449_297# r_SM_Main[1] _058_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: B w=1]]', 's: [connection X21/s =>[signal: Y w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__164__21 VGND r_SM_Main[0] _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: C w=1]]', 's: [connection X22/s =>[signal: Y w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__164__22 VGND r_SM_Main[1] _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: B w=1]]', 's: [connection X23/s =>[signal: Y w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__164__23 VGND r_SM_Main[0] _058_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _165_ with the contents of sky130_fd_sc_hd__nand2_4
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__165__0 _165__a_27_47# net10 _059_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__165__1 _165__a_27_47# net10 _059_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__165__2 _059_ net10 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__165__3 _059_ net10 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_27_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__165__4 VGND _058_ _165__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__165__5 VPWR net10 _059_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: Y w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: a_27_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__165__6 _059_ net10 _165__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__165__7 _165__a_27_47# _058_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_27_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__165__8 VGND _058_ _165__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: B w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__165__9 VPWR _058_ _059_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_47# w=1]]', 'g: [connection X10/g =>[signal: B w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__165__10 _165__a_27_47# _058_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: A w=1]]', 's: [connection X11/s =>[signal: Y w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__165__11 VPWR net10 _059_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: B w=1]]', 's: [connection X12/s =>[signal: Y w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__165__12 VPWR _058_ _059_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: Y w=1]]', 'g: [connection X13/g =>[signal: B w=1]]', 's: [connection X13/s =>[signal: VPWR w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__165__13 _059_ _058_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: Y w=1]]', 'g: [connection X14/g =>[signal: A w=1]]', 's: [connection X14/s =>[signal: a_27_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__165__14 _059_ net10 _165__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Y w=1]]', 'g: [connection X15/g =>[signal: B w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__165__15 _059_ _058_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _166_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__166__0 _166__a_891_413# _166__a_193_47# _166__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__166__1 _166__a_1059_315# _166__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__166__2 _166__a_466_413# _166__a_27_47# _166__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__166__3 _166__a_634_159# _166__a_27_47# _166__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__166__4 _166__a_381_47# _166__a_193_47# _166__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__166__5 VPWR _000_ _166__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__166__6 VPWR _166__a_466_413# _166__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__166__7 VGND _166__a_466_413# _166__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__166__8 _166__a_1017_47# _166__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__166__9 _166__a_1059_315# _166__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__166__10 _166__a_561_413# _166__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__166__11 VPWR _166__a_1059_315# net11 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__166__12 _166__a_891_413# _166__a_27_47# _166__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__166__13 _166__a_634_159# _166__a_193_47# _166__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__166__14 _166__a_592_47# _166__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__166__15 _166__a_466_413# _166__a_193_47# _166__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__166__16 VGND _166__a_27_47# _166__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__166__17 _166__a_381_47# _166__a_27_47# _166__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__166__18 _166__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__166__19 _166__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__166__20 VPWR _166__a_27_47# _166__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__166__21 VGND _000_ _166__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__166__22 _166__a_975_413# _166__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__166__23 VGND _166__a_1059_315# net11 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _167_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__167__0 _167__a_891_413# _167__a_193_47# _167__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__167__1 _167__a_1059_315# _167__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__167__2 _167__a_466_413# _167__a_27_47# _167__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__167__3 _167__a_634_159# _167__a_27_47# _167__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__167__4 _167__a_381_47# _167__a_193_47# _167__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__167__5 VPWR _001_ _167__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__167__6 VPWR _167__a_466_413# _167__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__167__7 VGND _167__a_466_413# _167__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__167__8 _167__a_1017_47# _167__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__167__9 _167__a_1059_315# _167__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__167__10 _167__a_561_413# _167__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__167__11 VPWR _167__a_1059_315# r_Clock_Count[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__167__12 _167__a_891_413# _167__a_27_47# _167__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__167__13 _167__a_634_159# _167__a_193_47# _167__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__167__14 _167__a_592_47# _167__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__167__15 _167__a_466_413# _167__a_193_47# _167__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__167__16 VGND _167__a_27_47# _167__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__167__17 _167__a_381_47# _167__a_27_47# _167__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__167__18 _167__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__167__19 _167__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__167__20 VPWR _167__a_27_47# _167__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__167__21 VGND _001_ _167__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__167__22 _167__a_975_413# _167__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__167__23 VGND _167__a_1059_315# r_Clock_Count[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _168_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__168__0 _168__a_891_413# _168__a_193_47# _168__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__168__1 _168__a_1059_315# _168__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__168__2 _168__a_466_413# _168__a_27_47# _168__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__168__3 _168__a_634_159# _168__a_27_47# _168__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__168__4 _168__a_381_47# _168__a_193_47# _168__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__168__5 VPWR _002_ _168__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__168__6 VPWR _168__a_466_413# _168__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__168__7 VGND _168__a_466_413# _168__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__168__8 _168__a_1017_47# _168__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__168__9 _168__a_1059_315# _168__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__168__10 _168__a_561_413# _168__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__168__11 VPWR _168__a_1059_315# r_Clock_Count[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__168__12 _168__a_891_413# _168__a_27_47# _168__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__168__13 _168__a_634_159# _168__a_193_47# _168__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__168__14 _168__a_592_47# _168__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__168__15 _168__a_466_413# _168__a_193_47# _168__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__168__16 VGND _168__a_27_47# _168__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__168__17 _168__a_381_47# _168__a_27_47# _168__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__168__18 _168__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__168__19 _168__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__168__20 VPWR _168__a_27_47# _168__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__168__21 VGND _002_ _168__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__168__22 _168__a_975_413# _168__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__168__23 VGND _168__a_1059_315# r_Clock_Count[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _169_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__169__0 _169__a_891_413# _169__a_193_47# _169__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__169__1 _169__a_1059_315# _169__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__169__2 _169__a_466_413# _169__a_27_47# _169__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__169__3 _169__a_634_159# _169__a_27_47# _169__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__169__4 _169__a_381_47# _169__a_193_47# _169__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__169__5 VPWR _003_ _169__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__169__6 VPWR _169__a_466_413# _169__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__169__7 VGND _169__a_466_413# _169__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__169__8 _169__a_1017_47# _169__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__169__9 _169__a_1059_315# _169__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__169__10 _169__a_561_413# _169__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__169__11 VPWR _169__a_1059_315# r_Clock_Count[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__169__12 _169__a_891_413# _169__a_27_47# _169__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__169__13 _169__a_634_159# _169__a_193_47# _169__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__169__14 _169__a_592_47# _169__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__169__15 _169__a_466_413# _169__a_193_47# _169__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__169__16 VGND _169__a_27_47# _169__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__169__17 _169__a_381_47# _169__a_27_47# _169__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__169__18 _169__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__169__19 _169__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__169__20 VPWR _169__a_27_47# _169__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__169__21 VGND _003_ _169__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__169__22 _169__a_975_413# _169__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__169__23 VGND _169__a_1059_315# r_Clock_Count[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _170_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__170__0 _170__a_891_413# _170__a_193_47# _170__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__170__1 _170__a_1059_315# _170__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__170__2 _170__a_466_413# _170__a_27_47# _170__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__170__3 _170__a_634_159# _170__a_27_47# _170__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__170__4 _170__a_381_47# _170__a_193_47# _170__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__170__5 VPWR _004_ _170__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__170__6 VPWR _170__a_466_413# _170__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__170__7 VGND _170__a_466_413# _170__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__170__8 _170__a_1017_47# _170__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__170__9 _170__a_1059_315# _170__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__170__10 _170__a_561_413# _170__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__170__11 VPWR _170__a_1059_315# r_Clock_Count[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__170__12 _170__a_891_413# _170__a_27_47# _170__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__170__13 _170__a_634_159# _170__a_193_47# _170__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__170__14 _170__a_592_47# _170__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__170__15 _170__a_466_413# _170__a_193_47# _170__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__170__16 VGND _170__a_27_47# _170__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__170__17 _170__a_381_47# _170__a_27_47# _170__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__170__18 _170__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__170__19 _170__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__170__20 VPWR _170__a_27_47# _170__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__170__21 VGND _004_ _170__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__170__22 _170__a_975_413# _170__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__170__23 VGND _170__a_1059_315# r_Clock_Count[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _171_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__171__0 _171__a_891_413# _171__a_193_47# _171__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__171__1 _171__a_1059_315# _171__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__171__2 _171__a_466_413# _171__a_27_47# _171__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__171__3 _171__a_634_159# _171__a_27_47# _171__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__171__4 _171__a_381_47# _171__a_193_47# _171__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__171__5 VPWR _005_ _171__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__171__6 VPWR _171__a_466_413# _171__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__171__7 VGND _171__a_466_413# _171__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__171__8 _171__a_1017_47# _171__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__171__9 _171__a_1059_315# _171__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__171__10 _171__a_561_413# _171__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__171__11 VPWR _171__a_1059_315# r_Clock_Count[4] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__171__12 _171__a_891_413# _171__a_27_47# _171__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__171__13 _171__a_634_159# _171__a_193_47# _171__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__171__14 _171__a_592_47# _171__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__171__15 _171__a_466_413# _171__a_193_47# _171__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__171__16 VGND _171__a_27_47# _171__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__171__17 _171__a_381_47# _171__a_27_47# _171__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__171__18 _171__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__171__19 _171__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__171__20 VPWR _171__a_27_47# _171__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__171__21 VGND _005_ _171__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__171__22 _171__a_975_413# _171__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__171__23 VGND _171__a_1059_315# r_Clock_Count[4] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _172_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__172__0 _172__a_891_413# _172__a_193_47# _172__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__172__1 _172__a_1059_315# _172__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__172__2 _172__a_466_413# _172__a_27_47# _172__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__172__3 _172__a_634_159# _172__a_27_47# _172__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__172__4 _172__a_381_47# _172__a_193_47# _172__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__172__5 VPWR _006_ _172__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__172__6 VPWR _172__a_466_413# _172__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__172__7 VGND _172__a_466_413# _172__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__172__8 _172__a_1017_47# _172__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__172__9 _172__a_1059_315# _172__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__172__10 _172__a_561_413# _172__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__172__11 VPWR _172__a_1059_315# r_Clock_Count[5] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__172__12 _172__a_891_413# _172__a_27_47# _172__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__172__13 _172__a_634_159# _172__a_193_47# _172__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__172__14 _172__a_592_47# _172__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__172__15 _172__a_466_413# _172__a_193_47# _172__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__172__16 VGND _172__a_27_47# _172__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__172__17 _172__a_381_47# _172__a_27_47# _172__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__172__18 _172__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__172__19 _172__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__172__20 VPWR _172__a_27_47# _172__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__172__21 VGND _006_ _172__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__172__22 _172__a_975_413# _172__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__172__23 VGND _172__a_1059_315# r_Clock_Count[5] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _173_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__173__0 _173__a_891_413# _173__a_193_47# _173__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__173__1 _173__a_1059_315# _173__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__173__2 _173__a_466_413# _173__a_27_47# _173__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__173__3 _173__a_634_159# _173__a_27_47# _173__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__173__4 _173__a_381_47# _173__a_193_47# _173__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__173__5 VPWR _007_ _173__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__173__6 VPWR _173__a_466_413# _173__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__173__7 VGND _173__a_466_413# _173__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__173__8 _173__a_1017_47# _173__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__173__9 _173__a_1059_315# _173__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__173__10 _173__a_561_413# _173__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__173__11 VPWR _173__a_1059_315# r_Clock_Count[6] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__173__12 _173__a_891_413# _173__a_27_47# _173__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__173__13 _173__a_634_159# _173__a_193_47# _173__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__173__14 _173__a_592_47# _173__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__173__15 _173__a_466_413# _173__a_193_47# _173__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__173__16 VGND _173__a_27_47# _173__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__173__17 _173__a_381_47# _173__a_27_47# _173__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__173__18 _173__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__173__19 _173__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__173__20 VPWR _173__a_27_47# _173__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__173__21 VGND _007_ _173__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__173__22 _173__a_975_413# _173__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__173__23 VGND _173__a_1059_315# r_Clock_Count[6] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _174_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__174__0 _174__a_891_413# _174__a_193_47# _174__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__174__1 _174__a_1059_315# _174__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__174__2 _174__a_466_413# _174__a_27_47# _174__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__174__3 _174__a_634_159# _174__a_27_47# _174__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__174__4 _174__a_381_47# _174__a_193_47# _174__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__174__5 VPWR _008_ _174__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__174__6 VPWR _174__a_466_413# _174__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__174__7 VGND _174__a_466_413# _174__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__174__8 _174__a_1017_47# _174__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__174__9 _174__a_1059_315# _174__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__174__10 _174__a_561_413# _174__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__174__11 VPWR _174__a_1059_315# r_Clock_Count[7] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__174__12 _174__a_891_413# _174__a_27_47# _174__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__174__13 _174__a_634_159# _174__a_193_47# _174__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__174__14 _174__a_592_47# _174__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__174__15 _174__a_466_413# _174__a_193_47# _174__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__174__16 VGND _174__a_27_47# _174__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__174__17 _174__a_381_47# _174__a_27_47# _174__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__174__18 _174__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__174__19 _174__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__174__20 VPWR _174__a_27_47# _174__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__174__21 VGND _008_ _174__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__174__22 _174__a_975_413# _174__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__174__23 VGND _174__a_1059_315# r_Clock_Count[7] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _175_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__175__0 _175__a_891_413# _175__a_193_47# _175__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__175__1 _175__a_1059_315# _175__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__175__2 _175__a_466_413# _175__a_27_47# _175__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__175__3 _175__a_634_159# _175__a_27_47# _175__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__175__4 _175__a_381_47# _175__a_193_47# _175__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__175__5 VPWR _080_ _175__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__175__6 VPWR _175__a_466_413# _175__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__175__7 VGND _175__a_466_413# _175__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__175__8 _175__a_1017_47# _175__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__175__9 _175__a_1059_315# _175__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__175__10 _175__a_561_413# _175__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__175__11 VPWR _175__a_1059_315# r_SM_Main[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__175__12 _175__a_891_413# _175__a_27_47# _175__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__175__13 _175__a_634_159# _175__a_193_47# _175__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__175__14 _175__a_592_47# _175__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__175__15 _175__a_466_413# _175__a_193_47# _175__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__175__16 VGND _175__a_27_47# _175__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__175__17 _175__a_381_47# _175__a_27_47# _175__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__175__18 _175__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__175__19 _175__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__175__20 VPWR _175__a_27_47# _175__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__175__21 VGND _080_ _175__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__175__22 _175__a_975_413# _175__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__175__23 VGND _175__a_1059_315# r_SM_Main[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _176_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__176__0 _176__a_891_413# _176__a_193_47# _176__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__176__1 _176__a_1059_315# _176__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__176__2 _176__a_466_413# _176__a_27_47# _176__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__176__3 _176__a_634_159# _176__a_27_47# _176__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__176__4 _176__a_381_47# _176__a_193_47# _176__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__176__5 VPWR _081_ _176__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__176__6 VPWR _176__a_466_413# _176__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__176__7 VGND _176__a_466_413# _176__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__176__8 _176__a_1017_47# _176__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__176__9 _176__a_1059_315# _176__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__176__10 _176__a_561_413# _176__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__176__11 VPWR _176__a_1059_315# r_SM_Main[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__176__12 _176__a_891_413# _176__a_27_47# _176__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__176__13 _176__a_634_159# _176__a_193_47# _176__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__176__14 _176__a_592_47# _176__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__176__15 _176__a_466_413# _176__a_193_47# _176__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__176__16 VGND _176__a_27_47# _176__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__176__17 _176__a_381_47# _176__a_27_47# _176__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__176__18 _176__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__176__19 _176__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__176__20 VPWR _176__a_27_47# _176__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__176__21 VGND _081_ _176__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__176__22 _176__a_975_413# _176__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__176__23 VGND _176__a_1059_315# r_SM_Main[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _177_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__177__0 _177__a_891_413# _177__a_193_47# _177__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__177__1 _177__a_1059_315# _177__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__177__2 _177__a_466_413# _177__a_27_47# _177__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__177__3 _177__a_634_159# _177__a_27_47# _177__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__177__4 _177__a_381_47# _177__a_193_47# _177__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__177__5 VPWR _082_ _177__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__177__6 VPWR _177__a_466_413# _177__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__177__7 VGND _177__a_466_413# _177__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__177__8 _177__a_1017_47# _177__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__177__9 _177__a_1059_315# _177__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__177__10 _177__a_561_413# _177__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__177__11 VPWR _177__a_1059_315# r_SM_Main[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__177__12 _177__a_891_413# _177__a_27_47# _177__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__177__13 _177__a_634_159# _177__a_193_47# _177__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__177__14 _177__a_592_47# _177__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__177__15 _177__a_466_413# _177__a_193_47# _177__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__177__16 VGND _177__a_27_47# _177__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__177__17 _177__a_381_47# _177__a_27_47# _177__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__177__18 _177__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__177__19 _177__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__177__20 VPWR _177__a_27_47# _177__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__177__21 VGND _082_ _177__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__177__22 _177__a_975_413# _177__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__177__23 VGND _177__a_1059_315# r_SM_Main[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _178_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__178__0 _178__a_891_413# _178__a_193_47# _178__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__178__1 _178__a_1059_315# _178__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__178__2 _178__a_466_413# _178__a_27_47# _178__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__178__3 _178__a_634_159# _178__a_27_47# _178__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__178__4 _178__a_381_47# _178__a_193_47# _178__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__178__5 VPWR _009_ _178__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__178__6 VPWR _178__a_466_413# _178__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__178__7 VGND _178__a_466_413# _178__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__178__8 _178__a_1017_47# _178__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__178__9 _178__a_1059_315# _178__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__178__10 _178__a_561_413# _178__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__178__11 VPWR _178__a_1059_315# net13 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__178__12 _178__a_891_413# _178__a_27_47# _178__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__178__13 _178__a_634_159# _178__a_193_47# _178__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__178__14 _178__a_592_47# _178__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__178__15 _178__a_466_413# _178__a_193_47# _178__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__178__16 VGND _178__a_27_47# _178__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__178__17 _178__a_381_47# _178__a_27_47# _178__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__178__18 _178__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__178__19 _178__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__178__20 VPWR _178__a_27_47# _178__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__178__21 VGND _009_ _178__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__178__22 _178__a_975_413# _178__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__178__23 VGND _178__a_1059_315# net13 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _179_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__179__0 _179__a_891_413# _179__a_193_47# _179__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__179__1 _179__a_1059_315# _179__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__179__2 _179__a_466_413# _179__a_27_47# _179__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__179__3 _179__a_634_159# _179__a_27_47# _179__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__179__4 _179__a_381_47# _179__a_193_47# _179__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__179__5 VPWR _010_ _179__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__179__6 VPWR _179__a_466_413# _179__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__179__7 VGND _179__a_466_413# _179__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__179__8 _179__a_1017_47# _179__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__179__9 _179__a_1059_315# _179__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__179__10 _179__a_561_413# _179__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__179__11 VPWR _179__a_1059_315# r_Bit_Index[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__179__12 _179__a_891_413# _179__a_27_47# _179__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__179__13 _179__a_634_159# _179__a_193_47# _179__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__179__14 _179__a_592_47# _179__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__179__15 _179__a_466_413# _179__a_193_47# _179__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__179__16 VGND _179__a_27_47# _179__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__179__17 _179__a_381_47# _179__a_27_47# _179__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__179__18 _179__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__179__19 _179__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__179__20 VPWR _179__a_27_47# _179__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__179__21 VGND _010_ _179__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__179__22 _179__a_975_413# _179__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__179__23 VGND _179__a_1059_315# r_Bit_Index[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _180_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__180__0 _180__a_891_413# _180__a_193_47# _180__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__180__1 _180__a_1059_315# _180__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__180__2 _180__a_466_413# _180__a_27_47# _180__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__180__3 _180__a_634_159# _180__a_27_47# _180__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__180__4 _180__a_381_47# _180__a_193_47# _180__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__180__5 VPWR _011_ _180__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__180__6 VPWR _180__a_466_413# _180__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__180__7 VGND _180__a_466_413# _180__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__180__8 _180__a_1017_47# _180__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__180__9 _180__a_1059_315# _180__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__180__10 _180__a_561_413# _180__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__180__11 VPWR _180__a_1059_315# r_Bit_Index[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__180__12 _180__a_891_413# _180__a_27_47# _180__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__180__13 _180__a_634_159# _180__a_193_47# _180__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__180__14 _180__a_592_47# _180__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__180__15 _180__a_466_413# _180__a_193_47# _180__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__180__16 VGND _180__a_27_47# _180__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__180__17 _180__a_381_47# _180__a_27_47# _180__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__180__18 _180__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__180__19 _180__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__180__20 VPWR _180__a_27_47# _180__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__180__21 VGND _011_ _180__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__180__22 _180__a_975_413# _180__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__180__23 VGND _180__a_1059_315# r_Bit_Index[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _181_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__181__0 _181__a_891_413# _181__a_193_47# _181__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__181__1 _181__a_1059_315# _181__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__181__2 _181__a_466_413# _181__a_27_47# _181__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__181__3 _181__a_634_159# _181__a_27_47# _181__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__181__4 _181__a_381_47# _181__a_193_47# _181__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__181__5 VPWR _012_ _181__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__181__6 VPWR _181__a_466_413# _181__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__181__7 VGND _181__a_466_413# _181__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__181__8 _181__a_1017_47# _181__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__181__9 _181__a_1059_315# _181__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__181__10 _181__a_561_413# _181__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__181__11 VPWR _181__a_1059_315# r_Bit_Index[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__181__12 _181__a_891_413# _181__a_27_47# _181__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__181__13 _181__a_634_159# _181__a_193_47# _181__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__181__14 _181__a_592_47# _181__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__181__15 _181__a_466_413# _181__a_193_47# _181__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__181__16 VGND _181__a_27_47# _181__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__181__17 _181__a_381_47# _181__a_27_47# _181__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__181__18 _181__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__181__19 _181__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__181__20 VPWR _181__a_27_47# _181__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__181__21 VGND _012_ _181__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__181__22 _181__a_975_413# _181__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__181__23 VGND _181__a_1059_315# r_Bit_Index[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _182_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__182__0 _182__a_891_413# _182__a_193_47# _182__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__182__1 _182__a_1059_315# _182__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__182__2 _182__a_466_413# _182__a_27_47# _182__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__182__3 _182__a_634_159# _182__a_27_47# _182__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__182__4 _182__a_381_47# _182__a_193_47# _182__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__182__5 VPWR _013_ _182__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__182__6 VPWR _182__a_466_413# _182__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__182__7 VGND _182__a_466_413# _182__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__182__8 _182__a_1017_47# _182__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__182__9 _182__a_1059_315# _182__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__182__10 _182__a_561_413# _182__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__182__11 VPWR _182__a_1059_315# r_TX_Data[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__182__12 _182__a_891_413# _182__a_27_47# _182__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__182__13 _182__a_634_159# _182__a_193_47# _182__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__182__14 _182__a_592_47# _182__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__182__15 _182__a_466_413# _182__a_193_47# _182__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__182__16 VGND _182__a_27_47# _182__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__182__17 _182__a_381_47# _182__a_27_47# _182__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__182__18 _182__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__182__19 _182__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__182__20 VPWR _182__a_27_47# _182__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__182__21 VGND _013_ _182__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__182__22 _182__a_975_413# _182__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__182__23 VGND _182__a_1059_315# r_TX_Data[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _183_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__183__0 _183__a_891_413# _183__a_193_47# _183__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__183__1 _183__a_1059_315# _183__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__183__2 _183__a_466_413# _183__a_27_47# _183__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__183__3 _183__a_634_159# _183__a_27_47# _183__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__183__4 _183__a_381_47# _183__a_193_47# _183__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__183__5 VPWR _014_ _183__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__183__6 VPWR _183__a_466_413# _183__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__183__7 VGND _183__a_466_413# _183__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__183__8 _183__a_1017_47# _183__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__183__9 _183__a_1059_315# _183__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__183__10 _183__a_561_413# _183__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__183__11 VPWR _183__a_1059_315# r_TX_Data[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__183__12 _183__a_891_413# _183__a_27_47# _183__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__183__13 _183__a_634_159# _183__a_193_47# _183__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__183__14 _183__a_592_47# _183__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__183__15 _183__a_466_413# _183__a_193_47# _183__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__183__16 VGND _183__a_27_47# _183__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__183__17 _183__a_381_47# _183__a_27_47# _183__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__183__18 _183__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__183__19 _183__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__183__20 VPWR _183__a_27_47# _183__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__183__21 VGND _014_ _183__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__183__22 _183__a_975_413# _183__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__183__23 VGND _183__a_1059_315# r_TX_Data[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _184_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__184__0 _184__a_891_413# _184__a_193_47# _184__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__184__1 _184__a_1059_315# _184__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__184__2 _184__a_466_413# _184__a_27_47# _184__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__184__3 _184__a_634_159# _184__a_27_47# _184__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__184__4 _184__a_381_47# _184__a_193_47# _184__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__184__5 VPWR _015_ _184__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__184__6 VPWR _184__a_466_413# _184__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__184__7 VGND _184__a_466_413# _184__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__184__8 _184__a_1017_47# _184__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__184__9 _184__a_1059_315# _184__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__184__10 _184__a_561_413# _184__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__184__11 VPWR _184__a_1059_315# r_TX_Data[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__184__12 _184__a_891_413# _184__a_27_47# _184__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__184__13 _184__a_634_159# _184__a_193_47# _184__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__184__14 _184__a_592_47# _184__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__184__15 _184__a_466_413# _184__a_193_47# _184__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__184__16 VGND _184__a_27_47# _184__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__184__17 _184__a_381_47# _184__a_27_47# _184__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__184__18 _184__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__184__19 _184__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__184__20 VPWR _184__a_27_47# _184__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__184__21 VGND _015_ _184__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__184__22 _184__a_975_413# _184__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__184__23 VGND _184__a_1059_315# r_TX_Data[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _185_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__185__0 _185__a_891_413# _185__a_193_47# _185__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__185__1 _185__a_1059_315# _185__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__185__2 _185__a_466_413# _185__a_27_47# _185__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__185__3 _185__a_634_159# _185__a_27_47# _185__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__185__4 _185__a_381_47# _185__a_193_47# _185__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__185__5 VPWR _016_ _185__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__185__6 VPWR _185__a_466_413# _185__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__185__7 VGND _185__a_466_413# _185__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__185__8 _185__a_1017_47# _185__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__185__9 _185__a_1059_315# _185__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__185__10 _185__a_561_413# _185__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__185__11 VPWR _185__a_1059_315# r_TX_Data[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__185__12 _185__a_891_413# _185__a_27_47# _185__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__185__13 _185__a_634_159# _185__a_193_47# _185__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__185__14 _185__a_592_47# _185__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__185__15 _185__a_466_413# _185__a_193_47# _185__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__185__16 VGND _185__a_27_47# _185__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__185__17 _185__a_381_47# _185__a_27_47# _185__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__185__18 _185__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__185__19 _185__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__185__20 VPWR _185__a_27_47# _185__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__185__21 VGND _016_ _185__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__185__22 _185__a_975_413# _185__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__185__23 VGND _185__a_1059_315# r_TX_Data[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _186_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__186__0 _186__a_891_413# _186__a_193_47# _186__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__186__1 _186__a_1059_315# _186__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__186__2 _186__a_466_413# _186__a_27_47# _186__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__186__3 _186__a_634_159# _186__a_27_47# _186__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__186__4 _186__a_381_47# _186__a_193_47# _186__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__186__5 VPWR _017_ _186__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__186__6 VPWR _186__a_466_413# _186__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__186__7 VGND _186__a_466_413# _186__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__186__8 _186__a_1017_47# _186__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__186__9 _186__a_1059_315# _186__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__186__10 _186__a_561_413# _186__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__186__11 VPWR _186__a_1059_315# r_TX_Data[4] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__186__12 _186__a_891_413# _186__a_27_47# _186__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__186__13 _186__a_634_159# _186__a_193_47# _186__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__186__14 _186__a_592_47# _186__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__186__15 _186__a_466_413# _186__a_193_47# _186__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__186__16 VGND _186__a_27_47# _186__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__186__17 _186__a_381_47# _186__a_27_47# _186__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__186__18 _186__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__186__19 _186__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__186__20 VPWR _186__a_27_47# _186__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__186__21 VGND _017_ _186__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__186__22 _186__a_975_413# _186__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__186__23 VGND _186__a_1059_315# r_TX_Data[4] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _187_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__187__0 _187__a_891_413# _187__a_193_47# _187__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__187__1 _187__a_1059_315# _187__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__187__2 _187__a_466_413# _187__a_27_47# _187__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__187__3 _187__a_634_159# _187__a_27_47# _187__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__187__4 _187__a_381_47# _187__a_193_47# _187__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__187__5 VPWR _018_ _187__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__187__6 VPWR _187__a_466_413# _187__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__187__7 VGND _187__a_466_413# _187__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__187__8 _187__a_1017_47# _187__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__187__9 _187__a_1059_315# _187__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__187__10 _187__a_561_413# _187__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__187__11 VPWR _187__a_1059_315# r_TX_Data[5] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__187__12 _187__a_891_413# _187__a_27_47# _187__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__187__13 _187__a_634_159# _187__a_193_47# _187__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__187__14 _187__a_592_47# _187__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__187__15 _187__a_466_413# _187__a_193_47# _187__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__187__16 VGND _187__a_27_47# _187__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__187__17 _187__a_381_47# _187__a_27_47# _187__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__187__18 _187__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__187__19 _187__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__187__20 VPWR _187__a_27_47# _187__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__187__21 VGND _018_ _187__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__187__22 _187__a_975_413# _187__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__187__23 VGND _187__a_1059_315# r_TX_Data[5] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _188_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__188__0 _188__a_891_413# _188__a_193_47# _188__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__188__1 _188__a_1059_315# _188__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__188__2 _188__a_466_413# _188__a_27_47# _188__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__188__3 _188__a_634_159# _188__a_27_47# _188__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__188__4 _188__a_381_47# _188__a_193_47# _188__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__188__5 VPWR _019_ _188__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__188__6 VPWR _188__a_466_413# _188__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__188__7 VGND _188__a_466_413# _188__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__188__8 _188__a_1017_47# _188__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__188__9 _188__a_1059_315# _188__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__188__10 _188__a_561_413# _188__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__188__11 VPWR _188__a_1059_315# r_TX_Data[6] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__188__12 _188__a_891_413# _188__a_27_47# _188__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__188__13 _188__a_634_159# _188__a_193_47# _188__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__188__14 _188__a_592_47# _188__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__188__15 _188__a_466_413# _188__a_193_47# _188__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__188__16 VGND _188__a_27_47# _188__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__188__17 _188__a_381_47# _188__a_27_47# _188__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__188__18 _188__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__188__19 _188__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__188__20 VPWR _188__a_27_47# _188__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__188__21 VGND _019_ _188__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__188__22 _188__a_975_413# _188__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__188__23 VGND _188__a_1059_315# r_TX_Data[6] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _189_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__189__0 _189__a_891_413# _189__a_193_47# _189__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__189__1 _189__a_1059_315# _189__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__189__2 _189__a_466_413# _189__a_27_47# _189__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__189__3 _189__a_634_159# _189__a_27_47# _189__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__189__4 _189__a_381_47# _189__a_193_47# _189__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__189__5 VPWR _020_ _189__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__189__6 VPWR _189__a_466_413# _189__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__189__7 VGND _189__a_466_413# _189__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__189__8 _189__a_1017_47# _189__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__189__9 _189__a_1059_315# _189__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__189__10 _189__a_561_413# _189__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__189__11 VPWR _189__a_1059_315# r_TX_Data[7] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__189__12 _189__a_891_413# _189__a_27_47# _189__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__189__13 _189__a_634_159# _189__a_193_47# _189__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__189__14 _189__a_592_47# _189__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__189__15 _189__a_466_413# _189__a_193_47# _189__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__189__16 VGND _189__a_27_47# _189__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__189__17 _189__a_381_47# _189__a_27_47# _189__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__189__18 _189__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__189__19 _189__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__189__20 VPWR _189__a_27_47# _189__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__189__21 VGND _020_ _189__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__189__22 _189__a_975_413# _189__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__189__23 VGND _189__a_1059_315# r_TX_Data[7] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _190_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__190__0 _190__a_891_413# _190__a_193_47# _190__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__190__1 _190__a_1059_315# _190__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__190__2 _190__a_466_413# _190__a_27_47# _190__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__190__3 _190__a_634_159# _190__a_27_47# _190__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__190__4 _190__a_381_47# _190__a_193_47# _190__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__190__5 VPWR _021_ _190__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__190__6 VPWR _190__a_466_413# _190__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__190__7 VGND _190__a_466_413# _190__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__190__8 _190__a_1017_47# _190__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__190__9 _190__a_1059_315# _190__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__190__10 _190__a_561_413# _190__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__190__11 VPWR _190__a_1059_315# net12 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__190__12 _190__a_891_413# _190__a_27_47# _190__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__190__13 _190__a_634_159# _190__a_193_47# _190__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__190__14 _190__a_592_47# _190__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__190__15 _190__a_466_413# _190__a_193_47# _190__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__190__16 VGND _190__a_27_47# _190__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__190__17 _190__a_381_47# _190__a_27_47# _190__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__190__18 _190__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__190__19 _190__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__190__20 VPWR _190__a_27_47# _190__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__190__21 VGND _021_ _190__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__190__22 _190__a_975_413# _190__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__190__23 VGND _190__a_1059_315# net12 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__buf_6
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_161_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 VGND input1_a_161_47# net1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_161_47# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_input1_1 VGND input1_a_161_47# net1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_161_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 net1 input1_a_161_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_161_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 input1_a_161_47# clkin VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: a_161_47# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_input1_4 VPWR clkin input1_a_161_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_161_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input1_5 VGND input1_a_161_47# net1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_161_47# w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X_input1_6 net1 input1_a_161_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_161_47# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X_input1_7 net1 input1_a_161_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VPWR w=1]]', 'g: [connection X8/g =>[signal: a_161_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X_input1_8 VPWR input1_a_161_47# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_161_47# w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_input1_9 input1_a_161_47# clkin VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: a_161_47# w=1]]', 's: [connection X10/s =>[signal: X w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X_input1_10 VPWR input1_a_161_47# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_161_47# w=1]]', 's: [connection X11/s =>[signal: X w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X_input1_11 VPWR input1_a_161_47# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: X w=1]]', 'g: [connection X12/g =>[signal: a_161_47# w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_input1_12 net1 input1_a_161_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VGND w=1]]', 'g: [connection X13/g =>[signal: A w=1]]', 's: [connection X13/s =>[signal: a_161_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X_input1_13 VGND clkin input1_a_161_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_161_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_input1_14 net1 input1_a_161_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: X w=1]]', 'g: [connection X15/g =>[signal: a_161_47# w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_input1_15 net1 input1_a_161_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing input10 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input10_0 VGND i_TX_DV input10_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input10_1 net10 input10_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input10_2 net10 input10_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input10_3 VPWR i_TX_DV input10_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 VGND i_TX_Byte.0 input2_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 net2 input2_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 net2 input2_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR i_TX_Byte.0 input2_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input3 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input3_0 VGND i_TX_Byte.1 input3_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input3_1 net3 input3_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input3_2 net3 input3_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input3_3 VPWR i_TX_Byte.1 input3_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input4 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input4_0 VGND i_TX_Byte.2 input4_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input4_1 net4 input4_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input4_2 net4 input4_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input4_3 VPWR i_TX_Byte.2 input4_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input5 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input5_0 VGND i_TX_Byte.3 input5_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input5_1 net5 input5_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input5_2 net5 input5_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input5_3 VPWR i_TX_Byte.3 input5_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input6 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input6_0 VGND i_TX_Byte.4 input6_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input6_1 net6 input6_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input6_2 net6 input6_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input6_3 VPWR i_TX_Byte.4 input6_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input7 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input7_0 VGND i_TX_Byte.5 input7_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input7_1 net7 input7_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input7_2 net7 input7_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input7_3 VPWR i_TX_Byte.5 input7_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input8 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input8_0 VGND i_TX_Byte.6 input8_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input8_1 net8 input8_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input8_2 net8 input8_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input8_3 VPWR i_TX_Byte.6 input8_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input9 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input9_0 VGND i_TX_Byte.7 input9_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input9_1 net9 input9_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input9_2 net9 input9_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input9_3 VPWR i_TX_Byte.7 input9_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing output11 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output11_0 o_TX_Active output11_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output11_1 output11_a_27_47# net11 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output11_2 VGND output11_a_27_47# o_TX_Active VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output11_3 o_TX_Active output11_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output11_4 VPWR output11_a_27_47# o_TX_Active VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output11_5 output11_a_27_47# net11 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output12 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output12_0 o_TX_Done output12_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output12_1 output12_a_27_47# net12 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output12_2 VGND output12_a_27_47# o_TX_Done VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output12_3 o_TX_Done output12_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output12_4 VPWR output12_a_27_47# o_TX_Done VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output12_5 output12_a_27_47# net12 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output13 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output13_0 o_TX_Serial output13_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output13_1 output13_a_27_47# net13 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output13_2 VGND output13_a_27_47# o_TX_Serial VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output13_3 o_TX_Serial output13_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output13_4 VPWR output13_a_27_47# o_TX_Serial VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output13_5 output13_a_27_47# net13 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
